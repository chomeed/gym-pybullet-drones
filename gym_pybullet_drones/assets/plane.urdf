Commit message: small large envs

File: gym_pybullet_drones/assets/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=6 6 10; visual mesh filename=plane.obj scale=1 1 1
